# Keil uVision project project.uvprojx, settings and files
target SPA_MB8(DLL) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c misc: --diag_suppress=546
  c include: .\Libs;.\Libs\mbedtls\include;.\User;.\User\App;.\User\Bsp;.\Libs\RL-ARM\RL-RTX\inc;.\Libs\RL-ARM\RL-RTX\portable;.\Libs\RL-ARM\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./User/App/: main.c myext.c stm32_it.c test.c
  group Bsp
    ./User/Bsp/: bsp.c bsp_adc.c bsp_ble.c bsp_ds1302.c bsp_e2p.c bsp_exti.c bsp_keypad.c bsp_power.c bsp_rtc.c bsp_spi.c bsp_spiflash.c bsp_uart.c bsp_uart1.c bsp_uart2.c bsp_uart3.c bsp_uart4.c bsp_uart5.c bsp_w5500.c
  group Config
    ./Libs/FatFS/: ffconf.h
    ./User/App/: RTX_Conf_CM.c
  group Kern
    ./User/Kern/: kern_api.c kern_json.c
  group Libs/cjson
    ./Libs/cjson/: cJSON.c
  group Libs/FatFS
    ./Libs/FatFS/: diskio.c ff.c fs.c
  group Libs/KuFrame
    ./Libs/KuFrame/: kualloc.c kubuffer.c kuconvert.c kustring.c kuutil.c kulist.c
  group Libs/mbedtls
    ./Libs/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_client.c psa_crypto_ecp.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Libs/W5500
    ./Libs/W5500/: dns.c httpClient.c mbedtlsClient.c socket.c utility.c w5500.c
  group Module
    ./User/Module/: flow.c memManager.c modBle.c modCrypto.c modDb.c modE2p.c modFile.c modFlash.c modKern.c modKeypad.c modMainBoard.c modRelayBoard.c modScanner.c modTime.c modUart.c modW5500.c modWeb.c
  group RL-RTX
    ./Libs/RL-ARM/RL-RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RL-RTX/portable
    ./Libs/RL-ARM/RL-RTX/portable/: HAL_CM3.c SVC_Table.s
  group Protocol
    ./User/Protocol/: protocoBle.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
